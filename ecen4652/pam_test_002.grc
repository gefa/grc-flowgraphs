options:
  parameters:
    generate_options: qt_gui
    id: pam_test_002
    output_language: python
    title: pam_test_002
  states: {}

blocks:
- name: beta
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: f0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: 1e3
  states: {state: disabled}
- name: k
  id: variable
  parameters:
    value: '5'
  states: {}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label0: '"rect"'
    label1: '"sinc"'
    label2: '"tri"'
    num_opts: '3'
    option1: '"sinc"'
    option2: '"tri"'
    type: string
    value: '"rect"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f0
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: waveform
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f0
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: waveform
  states: {state: disabled}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f0
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.hstack((np.zeros(k),1,np.zeros(k)))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import sys;sys.path.insert(1, '/home/gnuradio/grc-flowgraphs/ecen4652');import ptfun as ptfun
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: ptfun.pampt(sps,ptype,[k,beta])
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '[1,1,1,1,1]'
    type: fff
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    type: float
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    marker1: '0'
    size: '64'
    srate: samp_rate*sps
    type: float
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
