options:
  parameters:
    generate_options: qt_gui
    id: example004
    output_language: python
    title: example004
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tag1
  id: variable_tag_object
  parameters:
    key: pmt.intern("t1")
    offset: '0'
    src: pmt.intern("VecSrc")
    value: pmt.intern("0")
  states: {}
- name: tag2
  id: variable_tag_object
  parameters:
    key: pmt.intern("t2")
    offset: '0'
    src: pmt.intern("VecSrc")
    value: pmt.intern("0")
  states: {}
- name: tau
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.03'
    value: '0.01'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag1]'
    type: float
    vector: np.hstack((np.ones(int(tau*samp_rate)), np.zeros(int((0.1-tau)*samp_rate))))
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag2]'
    type: float
    vector: np.hstack((np.sin(np.linspace(0,np.pi,tau*samp_rate)), np.zeros(int((0.1-tau)*samp_rate))))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    grid: 'True'
    gui_hint: 1,1,1,1
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    nconnections: '2'
    size: 1024*2
    srate: samp_rate
    tr_delay: '0.01'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"t1"'
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_vector_source_x_0_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
