options:
  parameters:
    generate_options: no_gui
    id: ble_rx
    output_language: python
    title: ble receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1000000 * (2400 + Channel)
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: Channel
  id: parameter
  parameters:
    label: Channel
    short_id: f
    type: intx
    value: '2'
  states: {}
- name: ble_packet_sink_0
  id: ble_packet_sink
  parameters:
    i_chan_nbr: chan_select
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: chan_select
  id: parameter
  parameters:
    label: chan_select
    short_id: c
    type: intx
    value: '37'
  states: {}
- name: digital_gmsk_demod_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.030'
    mu: '0.5'
    omega_relative_limit: '0.200'
    samples_per_symbol: '2'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: '2000000'
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: samp_rate_in
    sync: none
    type: fc32
  states: {}

connections:
- [ble_packet_sink_0, out, blocks_message_debug_0_0, print_pdu]
- [ble_packet_sink_0, out, blocks_socket_pdu_0_0, pdus]
- [blocks_socket_pdu_1, pdus, blocks_socket_pdu_0_0, pdus]
- [digital_gmsk_demod_0_0, '0', ble_packet_sink_0, '0']
- [uhd_usrp_source_0_0, '0', digital_gmsk_demod_0_0, '0']

metadata:
  file_format: 1
