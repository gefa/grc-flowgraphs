options:
  parameters:
    category: '[IEEE802.11]'
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    title: WiFi rx
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2417000000*0+5170000000+5920000000*0
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: ieee802_11.signal_field()
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: max_symbols
  id: variable
  parameters:
    value: int(5 + 1 + ((16 + 800 * 8 + 6) * 2) / 24)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 10e6
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: int
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: chan_est
  id: parameter
  parameters:
    value: ieee802_11.LS
  states: {}
- name: encoding
  id: parameter
  parameters:
    type: intx
    value: ieee802_11.BPSK_1_2
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 5.89e9
  states: {state: disabled}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: sensitivity
  id: parameter
  parameters:
    type: eng_float
    value: '0.56'
  states: {}
- name: sync_long
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: sync_short
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: sensitivity
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dc_offs_enb0: '"True"'
    dev_addr: ''
    dev_args: '""'
    iq_imbal_enb0: '"True"'
    norm_gain0: 'True'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', sync_long, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', sync_short, '0']
- [blocks_divide_xx_0, '0', sync_short, '2']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', sync_short, '1']
- [blocks_moving_average_xx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_1, '0']
- [fft_vxx_0_1, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [sync_long, '0', blocks_stream_to_vector_0, '0']
- [sync_short, '0', blocks_delay_0, '0']
- [sync_short, '0', sync_long, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
