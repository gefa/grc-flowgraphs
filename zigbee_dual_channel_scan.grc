options:
  parameters:
    generate_options: no_gui
    id: zigbee_dual_channel_scan
    output_language: python
    realtime_scheduling: '1'
    title: zigbee_dual_channel_scan
  states: {}

blocks:
- name: base_freq
  id: variable
  parameters:
    value: int(2405e6)
  states: {}
- name: channel
  id: variable
  parameters:
    value: '11'
  states: {}
- name: channel_0
  id: variable
  parameters:
    value: '11'
  states: {state: disabled}
- name: channel_spacing
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: cmd_msg
  id: variable
  parameters:
    value: 'pmt.to_pmt({''antenna'': ant_msg, ''gain'': gain_msg, ''chan'': 0, ''freq'': freq_msg, ''lo_offset'': lo_msg})'
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(sample_rate/2000000)
  states: {}
- name: freq
  id: variable
  parameters:
    value: (base_freq+(channel_spacing*(channel-11)))
  states: {}
- name: freq_msg
  id: variable
  parameters:
    value: 1000000 * (2400 + channel_spacing * (channel - 10))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-75'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: ant_msg
  id: parameter
  parameters:
    label: Antena
    short_id: a
    type: str
    value: RX2
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor11.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor12.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: cmd_msg
    period: '1000000'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: sample_rate/2e6/decim
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: sample_rate/2e6/decim
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: gain_msg
  id: parameter
  parameters:
    label: gain_msg
    short_id: g
    type: eng_float
    value: '0.8'
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: ieee802_15_4_packet_sink_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: lo_msg
  id: parameter
  parameters:
    label: LO Offset
    type: eng_float
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Note zigbee ch.spacing is 5M. But we're jumping every two channels here.
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: ''
    center_freq0: freq+freq_offset
    dc_offs_enb0: 'True'
    dev_args: '""'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '57000'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_sub_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', ieee802_15_4_packet_sink_0_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', rational_resampler_xxx_1, '0']
- [ieee802_15_4_packet_sink_0, out, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0, out, blocks_message_debug_0_0, print_pdu]
- [ieee802_15_4_packet_sink_0_0, out, foo_wireshark_connector_0_0, in]
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0_0, '1']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_1, '0']

metadata:
  file_format: 1
