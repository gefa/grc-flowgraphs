options:
  parameters:
    generate_options: no_gui
    id: zigbee_triple_channel_rx
    output_language: python
    realtime_scheduling: '1'
    title: zigbee_triple_channel_rx
  states: {}

blocks:
- name: base_freq
  id: variable
  parameters:
    value: int(2410e6)
  states: {}
- name: channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: (base_freq+(channel_spacing*channel))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 12e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-75'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor12.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor14.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor13.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: sample_rate/2e6/decim
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: sample_rate/2e6/decim
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: sample_rate/2e6/decim
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: foo_wireshark_connector_0_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    affinity: '2'
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    affinity: '3'
    center_freq: freq_offset
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: ieee802_15_4_packet_sink_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: ieee802_15_4_packet_sink_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: ''
    center_freq0: freq+freq_offset
    dc_offs_enb0: 'True'
    dev_args: '""'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', single_pole_iir_filter_xx_0_0_0, '0']
- [analog_simple_squelch_cc_1, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_sub_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', ieee802_15_4_packet_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', ieee802_15_4_packet_sink_0_0_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0_0, '0']
- [foo_wireshark_connector_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0_0, out, foo_wireshark_connector_0_0, in]
- [ieee802_15_4_packet_sink_0_0_0, out, foo_wireshark_connector_0_0_0, in]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0_0, '1']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_1, '0']

metadata:
  file_format: 1
