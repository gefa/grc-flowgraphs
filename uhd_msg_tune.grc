options:
  parameters:
    category: Custom
    description: Tune a UHD source from a QT sink via messages (double-click a frequency to tune)
    generate_options: no_gui
    id: uhd_msg_tune
    output_language: python
    title: UHD Message Tuner
  states: {}

blocks:
- name: ant_msg
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    num_opts: '2'
    option1: RX2
    type: string
    value: TX/RX
  states: {state: disabled}
- name: channel
  id: variable
  parameters:
    value: '11'
  states: {}
- name: cmd_msg
  id: variable
  parameters:
    value: 'pmt.to_pmt({''antenna'': ant_msg, ''gain'': gain_msg, ''chan'': 0, ''freq'': freq_msg, ''lo_offset'': lo_msg})'
  states: {}
- name: freq_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    type: real
    value: initial_fc
  states: {state: disabled}
- name: freq_msg
  id: variable
  parameters:
    value: 1000000 * (2400 + 5 * (channel - 10))
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: gain_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    type: real
    value: gain
  states: {state: disabled}
- name: initial_fc
  id: variable
  parameters:
    value: 1000000 * (2400 + 5 * (11 - 10))
  states: {}
- name: lo_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: LO Offset
    type: real
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: ant_msg
  id: parameter
  parameters:
    label: Antena
    short_id: a
    type: str
    value: RX2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: cmd_msg
    period: '500'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: channel
  id: parameter
  parameters:
    label: channel
    short_id: c
    type: intx
    value: '11'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: freq_msg
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: intx
    value: 1000000 * (2400 + 5 * (channel - 10))
  states: {state: disabled}
- name: gain_msg
  id: parameter
  parameters:
    label: gain_msg
    short_id: g
    type: eng_float
    value: '0.8'
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: lo_msg
  id: parameter
  parameters:
    label: LO Offset
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: initial_fc
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: ''
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-120'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: initial_fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_
    port: '8080'
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '57000'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
