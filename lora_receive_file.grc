options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_file
    output_language: python
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: '868000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radio/workspace/docker-gnuradio-3.8/gnuradio/gr-lora_sdr/lora_9043_2msps.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/radio/workspace/gr-lora_rpp0/apps/example-trace.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_controller_0
  id: lora_controller
  parameters: {}
  states: {state: disabled}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_lora_receiver_1
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: 868e6
    channel_list: '[''868.1e6'']'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 1e6
    sf: '7'
  states: {state: disabled}
- name: lora_message_file_sink_0
  id: lora_message_file_sink
  parameters:
    path: ''
  states: {state: disabled}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {}
- name: lora_message_socket_source_0
  id: lora_message_socket_source
  parameters:
    addr: 127.0.0.1
    port: '40868'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', lora_lora_receiver_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print_pdu]
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
